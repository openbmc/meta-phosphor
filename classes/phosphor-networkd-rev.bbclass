SRC_URI += "git://github.com/openbmc/phosphor-networkd"
SRCREV = "abbd85cac576b2f48c4f27eee4a4771ab2777926"
