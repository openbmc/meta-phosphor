SRCREV ?= "c6fa1ddde0441c6c0d6129c8b97b25bd501afc90"
SKELETON_URI ?= "git://github.com/openbmc/skeleton"
