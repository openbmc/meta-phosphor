https_certificate_dir="${sysconfdir}/ssl/certs/https/"
