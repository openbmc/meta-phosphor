DEPENDS_remove = "rrdtool"
DEPENDS_append = " rrdtool-minimal"
