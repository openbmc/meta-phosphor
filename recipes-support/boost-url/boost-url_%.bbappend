EXTRA_OECMAKE += "-DBOOST_URL_STANDALONE=ON"
