FILESEXTRAPATHS_prepend_df-phosphor-mmc := "${THISDIR}/${PN}:"
